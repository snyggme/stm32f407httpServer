# Keil uVision project stm32f407.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Libs\inc;.\Libs\src;..\STM32F407_Test;.\Libs;.\FreeRTOS;.\FreeRTOS\include;.\lwip;.\lwip\port;.\lwip\port\include;.\lwip\src;.\lwip\src\api;.\lwip\src\core;.\lwip\src\core\ipv4;.\lwip\src\include;.\lwip\src\include\lwip;.\lwip\src\include\netif;.\lwip\src\include\posix\sys;.\lwip\src\include\posix;.\lwip\src\netif\ppp;.\STM32F4x7_ETH_Driver\inc;.\STM32F4x7_ETH_Driver\src;.\lwip\port\include\arch;.\lwip\src\netif;.\lwip\src\include\ipv4;.\lwip\src\include\ipv4\lwip
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StdPeriph
    ./Libs/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group main
    ./: main.c http_server.c stm32f4xx_it.c lwipopts.h main.h fs.c fsdata.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group LwIP
    ./lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ./lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ./lwip/src/netif/: etharp.c slipif.c
    ./lwip/port/: ethernetif.c sys_arch.c
  group STM32F4x7_ETH_Driver
    ./: stm32f4x7_eth_bsp.c
    ./STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
